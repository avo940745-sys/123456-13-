# Keil uVision project 123456第13届.uvproj, settings and files
target 123456第13届 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 123456第13届 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group Driver
    ./: STARTUP.A51
    ../Driver/: Init.c Init.h Key.c Key.h Led.c Led.h Seg.c Seg.h ds1302.c ds1302.h onewire.c onewire.h
  group User
    ./: main.c
